# IAR project ProjFinal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.CCIncludePath2: ..\..\ThreadX\common\inc; ..\..\ThreadX\ports\cortex_m4\iar\inc; ..\..\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ProjFinal.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\cassi\Documents\UTFPR\Sistemas Embarcados\pieraqua_ELF74\Lab5\Tiva.icf
  ILINK.IlinkAdditionalLibs: ..\..\ThreadX\ports\cortex_m4\iar\example_build\Debug\Exe\tx.a; ..\..\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Headers
    ./: gpio.h SistemaConfiguracao.h SistemaControleSaidas.h SistemaControleTemperatura.h SistemaControleVentilacao.h SistemaInterfaceGrafica.h SistemaMonitoramento.h
    ../Lab2/src/: system.h
  group Source
    ./: gendefs.c gpio.c main.c SistemaConfiguracao.c SistemaControleSaidas.c SistemaControleTemperatura.c SistemaControleVentilacao.c SistemaInterfaceGrafica.c SistemaMonitoramento.c startup_ewarm.c tx_initialize_low_level.s
    ../Lab2/src/: system.c
