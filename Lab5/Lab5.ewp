# IAR project Lab5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.CCIncludePath2: ..\..\ThreadX\common\inc; ..\..\ThreadX\ports\cortex_m4\iar\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab5.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Tiva.icf
  ILINK.IlinkAdditionalLibs: ..\..\ThreadX\ports\cortex_m4\iar\example_build\Debug\Exe\tx.a; ..\..\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source
    Source/: sample_threadx.c startup_ewarm.c tx_initialize_low_level.s
